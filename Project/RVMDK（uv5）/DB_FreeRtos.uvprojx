# Keil uVision project DB_FreeRtos.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DB_FreeRtos +hex
  AfterMake: D:\keil_c51\ARM\ARMCC\bin\fromelf.exe --bin -o G:\STM32_Project\SD_FreeRtos\Output\sd.bin  G:\STM32_Project\SD_FreeRtos\Output\**.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\..\Libraries\CMSIS;..\..\FreeRtos;..\..\FreeRtos\include;..\..\User;..\..\Libraries\FWlib\src;..\..\Libraries\FWlib\inc;..\..\FatFs;..\..\FatFs\option
  memory RVCT4: ROM 0x8001000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../../User/: main.c stm32f10x_it.c usart.c freertos.c gpio.c iic.c sht20.c delay.c bd_rnss.c jy901.c tf.c
  group STARTUP
    ../../Libraries/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DOC
    ../../Doc/: Readme.txt
  group FREERTOS
    ../../FreeRtos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c port.c heap_2.c
  group FATS
    ../../FatFs/: diskio.c ff.c
    ../../FatFs/option/: ccsbcs.c
